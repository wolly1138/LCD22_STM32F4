# IAR project LED.ewp, settings and files
configuration LED (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; D:\THUA\development\IAR_works\LED\Config; D:\THUA\development\IAR_works\LED\GUI\AntiAlias; D:\THUA\development\IAR_works\LED\GUI\ConvertColor; D:\THUA\development\IAR_works\LED\GUI\ConvertMono; D:\THUA\development\IAR_works\LED\GUI\Core; D:\THUA\development\IAR_works\LED\GUI\Font; D:\THUA\development\IAR_works\LED\GUI\JPEG; D:\THUA\development\IAR_works\LED\GUI\LCDDriver; D:\THUA\development\IAR_works\LED\GUI\MemDev; D:\THUA\development\IAR_works\LED\GUI\MultiLayer; D:\THUA\development\IAR_works\LED\GUI\Widget; D:\THUA\development\IAR_works\LED\GUI\WM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: LED.srec
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AntiAlias
    ../GUI/AntiAlias/: GUIAAArc.c GUIAAChar.c GUIAAChar2.c GUIAAChar4.c GUIAACircle.c GUIAALib.c GUIAALine.c GUIAAPoly.c GUIAAPolyOut.c
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f446xx.s
  group Application/User
    ../Src/: freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c
  group Config
    ../Config/: GUI_X.c GUIConf.h GUITouchConf.h LCDConf.h
  group ConvertColor
    ../GUI/ConvertColor/: LCDP111.c LCDP222.c LCDP233.c LCDP323.c LCDP332.c LCDP444_12.c LCDP444_12_1.c LCDP444_16.c LCDP555.c LCDP556.c LCDP565.c LCDP655.c LCDP8666.c LCDP8666_1.c LCDPM233.c LCDPM323.c LCDPM332.c LCDPM444_12.c LCDPM444_16.c LCDPM555.c LCDPM556.c LCDPM565.c LCDPM655.c
  group ConvertMono
    ../GUI/ConvertMono/: LCDP0.c LCDP2.c LCDP4.c
  group Core
    ../GUI/Core/: GUI.h GUI2DLib.c GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_ConfDefaults.h GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_FontIntern.h GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_Private.h GUI_Protected.h GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_VNC.h GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI_X.h GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIDebug.h GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIType.h GUIUC0.c GUIVal.c GUIValf.c GUIVersion.h LCD.c LCD.h LCD_API.c LCD_ConfDefaults.h LCD_DrawBitmap_565.c LCD_DrawBitmap_M565.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Private.h LCD_Protected.h LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c LCDSIM.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Font
    ../GUI/Font/: F08_1.c F08_ASCII.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c F4x6.c F6x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F8x8.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group LCDDriver
    ../GUI/LCDDriver/: LCD22.c LCD22.h LCDDummy.c LCDNull.c LCDWin.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
